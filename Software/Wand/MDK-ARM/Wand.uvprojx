# Keil uVision project Wand.uvprojx, settings and files
target Wand (6160000::V6.16::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Wand +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/W25Q16;../Drivers/nnom/port;../Drivers/nnom/inc/layers;../Drivers/nnom/inc;../Drivers/mpu6050;../Drivers/key;../Drivers/IR_Decoder/include;..\Drivers\RGB;..\Drivers\mpu6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group W25Q16
    ../Drivers/W25Q16/: W25Q16.c
  group nnom
    ../Drivers/nnom/src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_reshape.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
    ../Drivers/nnom/src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
    ../Drivers/nnom/src/backends/: nnom_local.c nnom_local_q15.c
  group key
    ../Drivers/key/: key.c
  group IR_Decoder
    ../Drivers/IR_Decoder/: ir_ac_apply.c ir_ac_binary_parse.c ir_ac_build_frame.c ir_ac_control.c ir_ac_parse_forbidden_info.c ir_ac_parse_frame_info.c ir_ac_parse_parameter.c ir_decode.c ir_tv_control.c ir_utils.c
  group RGB
    ../Drivers/RGB/: RGB.c
  group mpu6050
    ../Drivers/mpu6050/: mpu6050.c
software components: CMSIS:CORE 6.1.0
